Commit message: tweak rendering

File: test/urdf/doublependulum.urdf (robot description, URDF)
Before this commit: robot DoublePendulum, 3 links, 2 joints
Joints:
- joint elbow: origin xyz=0 .1 -1 -> xyz=.1 0 -1
- joint shoulder: origin xyz=0 .15 0 -> xyz=.15 0 0
